# Keil uVision project nucleo-h743zi.uvprojx, settings and files
target stm32-nucleo-h743zi (6160000::V6.16::ARMCLANG)
  device: STM32H743ZITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: blinky_button
  AfterMake: fromelf --bin --output .\build_nucleo-h743zi\blinky_button.bin .\build_nucleo-h743zi\blinky_button.axf
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32H743xx
  c include: ..;..\..\..\inc;..\..\..\3rd_party\FreeRTOS-Kernel\include;..\..\..\3rd_party\FreeRTOS-Kernel\portable\GCC\ARM_CM7\r0p1;..\..\..\3rd_party\CMSIS\Include;..\..\..\3rd_party\nucleo-h743zi
  asm define: Stack_Size=2048 Heap_Size=16
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  link misc: --entry Reset_Handler
  group Applicatioin
    ../: bsp.h FreeRTOSConfig.h main.c bsp_nucleo-h743zi.c
  group nucleo-h743zi
    ../../../3rd_party/nucleo-h743zi/: stm32h743xx.h system_stm32h7xx.c system_stm32h7xx.h
    ../../../3rd_party/nucleo-h743zi/arm/: startup_stm32h743xx.s
  group FreeAct
    ../../../inc/: FreeAct.h
    ../../../src/: FreeAct.c
  group FreeRTOS-Kernel
    ../../../3rd_party/FreeRTOS-Kernel/: list.c queue.c tasks.c timers.c
    ../../../3rd_party/FreeRTOS-Kernel/portable/GCC/ARM_CM7/r0p1/: port.c portmacro.h
