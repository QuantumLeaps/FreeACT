# Keil uVision project ek-tm4c123gxl.uvprojx, settings and files
target ek-tm4c123gxl (6160000::V6.16::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: blinky_button
  c flags: OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: EFM32PG1B200F256GM48=1 __FPU_PRESENT
  c include: ..;..\..\..\inc;..\..\..\3rd_party\FreeRTOS-Kernel\include;..\..\..\3rd_party\FreeRTOS-Kernel\portable\GCC\ARM_CM4F;..\..\..\3rd_party\CMSIS\Include;..\..\..\3rd_party\ek-tm4c123gxl
  asm define: Stack_Size=1024 Heap_Size=16
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry Reset_Handler
  group Applicatioin
    ../: bsp.h FreeRTOSConfig.h main.c bsp_ek-tm4c123gxl.c
  group FreeAct
    ../../../inc/: FreeAct.h
    ../../../src/: FreeAct.c
  group FreeRTOS
    ../../../3rd_party/FreeRTOS-Kernel/: list.c queue.c tasks.c timers.c
    ../../../3rd_party/FreeRTOS-Kernel/portable/GCC/ARM_CM4F/: port.c
  group ek-tm4c123gxl
    ../../../3rd_party/ek-tm4c123gxl/: system_TM4C123GH6PM.c TM4C123GH6PM.h
    ../../../3rd_party/ek-tm4c123gxl/arm/: startup_TM4C123GH6PM.s
