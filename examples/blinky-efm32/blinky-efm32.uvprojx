# Keil uVision project blinky-efm32.uvprojx, settings and files
target blinky-dbg (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: EFM32PG1B200F256GM48 Silicon Labs
  pack: SiliconLabs.EFM32PG1B_DFP.5.5.0
  cpu: IRAM(0x20000000,0x00008000) IROM(0x00000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: blinky-ef32
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: EFM32PG1B200F256GM48=1 __FPU_PRESENT
  c include: .;..\..\inc;..\..\3rd_party\FreeRTOS\Source\include;..\..\3rd_party\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\3rd_party\CMSIS\Include;..\..\3rd_party\efm32pg1b
  asm define: Stack_Size=1024 Heap_Size=16
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry Reset_Handler
  group Applicatioin
    ./: bsp.c bsp.h FreeRTOSConfig.h main.c
  group FreeAct
    ../../inc/: FreeAct.h
    ../../src/: FreeAct.c
  group FreeRTOS
    ../../3rd_party/FreeRTOS/Source/: list.c queue.c tasks.c
    ../../3rd_party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group efm32pg1b
    ../../3rd_party/efm32pg1b/: em_cmu.c em_emu.c em_gpio.c em_int.c em_rtcc.c em_system.c system_efm32pg1b.c
    ../../3rd_party/efm32pg1b/armclang/: startup_efm32pg1b.s
